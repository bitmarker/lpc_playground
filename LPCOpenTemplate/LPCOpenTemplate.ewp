# IAR project LPCOpenTemplate.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC11C24FBD48_301 NXP LPC11C24FBD48_301
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCIncludePath2: lpcopen\lpc_core\lpc_chip\chip_11xx; lpcopen\lpc_core\lpc_chip\chip_common; lpcopen\lpc_core\lpc_chip; lpcopen\CMSIS\CMSIS\Include; lpcopen\lpc_core\lpc_chip\chip_11xx\config_11cxx
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: lpcopen\lpc_core\lpc_chip\chip_11xx\config_11cxx
  OBJCOPY.OOCOutputFile: LPCOpenTemplate.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    lpcopen/applications/lpc11xx/startup_code/: iar_startup_lpc11xx.s sysinit.c
    ./: main.c
  group Libs
    lpcopen/lpc_core/lpc_chip/chip_11xx/iar_output/chip_11cxx_lib/Exe/: chip_11cxx_lib.a
  group Sensors
    ./: i2c_helper.c i2c_helper.h MCP9808.c MCP9808.h
