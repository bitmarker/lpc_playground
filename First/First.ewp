# IAR project First.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC11C24FBD48_301 NXP LPC11C24FBD48_301
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCIncludePath2: D:\20_Development\01_Embedded\LPC\lpcopen_v2_00a_keil_iar_nxp_lpcxpresso_11c24\software\lpc_core\lpc_chip\chip_11xx\config_11cxx; D:\20_Development\01_Embedded\LPC\lpcopen_v2_00a_keil_iar_nxp_lpcxpresso_11c24\software\lpc_core\lpc_chip\chip_common; D:\20_Development\01_Embedded\LPC\lpcopen_v2_00a_keil_iar_nxp_lpcxpresso_11c24\software\lpc_core\lpc_chip\chip_11xx; D:\20_Development\01_Embedded\LPC\lpcopen_v2_00a_keil_iar_nxp_lpcxpresso_11c24\software\CMSIS\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: D:\20_Development\01_Embedded\LPC\lpcopen_v2_00a_keil_iar_nxp_lpcxpresso_11c24\software\lpc_core\lpc_chip\chip_11xx\config_11cxx
  OBJCOPY.OOCOutputFile: First.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../lpcopen_v2_00a_keil_iar_nxp_lpcxpresso_11c24/applications/lpc11xx/startup_code/: iar_startup_lpc11xx.s sysinit.c
    ./: main.c swo.c
  group lib
    ../lpcopen_v2_00a_keil_iar_nxp_lpcxpresso_11c24/software/lpc_core/lpc_chip/chip_11xx/iar_output/chip_11cxx_lib/Exe/: chip_11cxx_lib.a
